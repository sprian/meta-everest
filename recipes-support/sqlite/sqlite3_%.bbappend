CFLAGS:append = " -DSQLITE_ENABLE_DBSTAT_VTAB"
